# Keil uVision project usb_host_keyboard.uvproj, settings and files
target usb_host_keyboard (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_host_keyboard
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_keyboard.bin .\rvmdk\usb_host_keyboard.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RA1
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_host_keyboard.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: cfal96x64x16.c
    ./: startup_rvmdk.S usb_host_keyboard.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
