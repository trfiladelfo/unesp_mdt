# Keil uVision project enet_uip.uvproj, settings and files
target enet_uip (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_uip
  AfterMake: fromelf --bin --output .\rvmdk\enet_uip.bin .\rvmdk\enet_uip.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 DEBUG_OUTPUT UIP_OFFLOAD_ICMP_CHKSUM
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\uip-1.0\apps;..\..\..\..\third_party\uip-1.0\uip;..\..\..\..\third_party\uip-1.0;..\..\..\..\utils;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_uip.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../third_party/uip-1.0/apps/dhcpc/: dhcpc.c
    ./: enet_uip.c startup_rvmdk.S
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../third_party/uip-1.0/apps/httpd/: httpd.c
    ../../../../utils/: uartstdio.c ustdlib.c
    ../../../../third_party/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
