# Keil uVision project usb_dev_bulk.uvproj, settings and files
target usb_dev_bulk (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_dev_bulk
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_bulk.bin .\rvmdk\usb_dev_bulk.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: usb_dev_bulk.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ./: startup_rvmdk.S usb_bulk_structs.c usb_dev_bulk.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
