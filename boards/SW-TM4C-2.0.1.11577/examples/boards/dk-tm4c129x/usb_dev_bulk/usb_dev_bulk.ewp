# IAR project usb_dev_bulk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_bulk.bin
  ILINK.IlinkOutputFile: usb_dev_bulk.out
  ILINK.IlinkIcfFile: usb_dev_bulk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ./: startup_ewarm.c usb_bulk_structs.c usb_dev_bulk.c
    ../../../../utils/: uartstdio.c ustdlib.c
