# Keil uVision project sd_card.uvproj, settings and files
target sd_card (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sd_card
  AfterMake: fromelf --bin --output .\rvmdk\sd_card.bin .\rvmdk\sd_card.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 ENABLE_LFN UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: sd_card.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../third_party/fatfs/src/option/: cc932.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../../../../third_party/fatfs/src/: ff.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c129x.c
    ./: sd_card.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
