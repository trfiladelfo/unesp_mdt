# Keil uVision project qs_weather.uvproj, settings and files
target qs_weather (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: qs_weather
  AfterMake: fromelf --bin --output .\rvmdk\qs_weather.bin .\rvmdk\qs_weather.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 LWIP_1_4_1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: qs_weather.sct
  link misc: --entry Reset_Handler
  group Source
    ./: eth_client.c images.c json.c qs_weather.c startup_rvmdk.S
    ../../../../utils/: flash_pb.c locator.c lwiplib.c uartstdio.c ustdlib.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
