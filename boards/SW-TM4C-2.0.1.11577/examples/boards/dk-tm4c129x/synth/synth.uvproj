# Keil uVision project synth.uvproj, settings and files
target synth (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: synth
  AfterMake: fromelf --bin --output .\rvmdk\synth.bin .\rvmdk\synth.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: synth.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c sound.c touch.c
    ../../../../utils/: sine.c
    ./: startup_rvmdk.S synth.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
