# Keil uVision project boot_demo_usb.uvproj, settings and files
target boot_demo_usb (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo_usb
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo_usb.bin .\rvmdk\boot_demo_usb.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boot_demo_usb.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo_usb.c startup_rvmdk.S usb_hiddfu_structs.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
