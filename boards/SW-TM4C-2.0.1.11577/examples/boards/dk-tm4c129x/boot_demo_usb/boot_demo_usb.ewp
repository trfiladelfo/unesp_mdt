# IAR project boot_demo_usb.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: boot_demo_usb.bin
  ILINK.IlinkOutputFile: boot_demo_usb.out
  ILINK.IlinkIcfFile: boot_demo_usb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ./: boot_demo_usb.c startup_ewarm.c usb_hiddfu_structs.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
