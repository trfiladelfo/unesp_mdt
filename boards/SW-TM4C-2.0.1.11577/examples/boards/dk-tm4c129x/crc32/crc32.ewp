# IAR project crc32.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: crc32.bin
  ILINK.IlinkOutputFile: crc32.out
  ILINK.IlinkIcfFile: crc32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: crc32.c startup_ewarm.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../utils/: uartstdio.c
