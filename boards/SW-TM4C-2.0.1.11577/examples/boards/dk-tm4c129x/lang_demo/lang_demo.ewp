# IAR project lang_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_SNOWFLAKE_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\third_party\fonts\lang_demo; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lang_demo.bin
  ILINK.IlinkOutputFile: lang_demo.out
  ILINK.IlinkIcfFile: lang_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../../../../third_party/fonts/lang_demo/: fontcustom14pt.c fontcustom20pt.c fontcustomr14pt.c fontcustomr20pt.c langremap.c language.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ./: images.c lang_demo.c startup_ewarm.c
    ../../../../utils/: ustdlib.c
