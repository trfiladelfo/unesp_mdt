# Keil uVision project fontview.uvproj, settings and files
target fontview (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: fontview
  AfterMake: fromelf --bin --output .\rvmdk\fontview.bin .\rvmdk\fontview.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party\fonts\ofl;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: fontview.sct
  link misc: --entry Reset_Handler
  group Source
    ./: fatwrapper.c fontview.c startup_rvmdk.S
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fonts/ofl/fonts/: fontcjktest20pt.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c129x.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
