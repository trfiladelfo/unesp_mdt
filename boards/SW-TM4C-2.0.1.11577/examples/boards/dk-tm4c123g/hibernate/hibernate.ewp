# IAR project hibernate.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: hibernate.bin
  ILINK.IlinkOutputFile: hibernate.out
  ILINK.IlinkIcfFile: hibernate.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../drivers/: buttons.c cfal96x64x16.c
    ./: hibernate.c startup_ewarm.c
    ../../../../utils/: uartstdio.c ustdlib.c
