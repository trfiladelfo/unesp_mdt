# Keil uVision project can.uvproj, settings and files
target can (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: can
  AfterMake: fromelf --bin --output .\rvmdk\can.bin .\rvmdk\can.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: can.sct
  link misc: --entry Reset_Handler
  group Source
    ./: can.c startup_rvmdk.S
    ../drivers/: cfal96x64x16.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
