# Keil uVision project qs-logger.uvproj, settings and files
target qs-logger (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: qs-logger
  AfterMake: fromelf --bin --output .\rvmdk\qs-logger.bin .\rvmdk\qs-logger.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: qs-logger.sct
  link misc: --entry Reset_Handler
  group Source
    ./: acquire.c clocksetwidget.c flashstore.c images.c menus.c qs-logger.c startup_rvmdk.S stripchartmanager.c usb_serial_structs.c usbserial.c usbstick.c
    ../drivers/: buttons.c cfal96x64x16.c slidemenuwidget.c stripchartwidget.c
    ../../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
