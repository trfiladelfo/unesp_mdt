# Keil uVision project sd_card.uvproj, settings and files
target sd_card (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: sd_card
  AfterMake: fromelf --bin --output .\rvmdk\sd_card.bin .\rvmdk\sd_card.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1 ENABLE_LFN
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: sd_card.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../third_party/fatfs/src/option/: cc932.c
    ../drivers/: cfal96x64x16.c
    ../../../../utils/: cmdline.c uartstdio.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c123g.c
    ./: sd_card.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
