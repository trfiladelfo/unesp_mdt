# Keil uVision project boot_demo1.uvproj, settings and files
target boot_demo1 (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo1
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo1.bin .\rvmdk\boot_demo1.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\bget;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: boot_demo1.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo1.c startup_rvmdk.S
    ../drivers/: cfal96x64x16.c
    ../../../../utils/: ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
