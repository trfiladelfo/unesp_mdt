# IAR project mpu_fault.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..; ..\..\..\..
  OBJCOPY.OOCOutputFile: mpu_fault.bin
  ILINK.IlinkOutputFile: mpu_fault.out
  ILINK.IlinkIcfFile: mpu_fault.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: mpu_fault.c startup_ewarm.c
    ../../../../utils/: uartstdio.c
