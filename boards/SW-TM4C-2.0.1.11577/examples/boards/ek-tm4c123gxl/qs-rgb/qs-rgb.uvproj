# Keil uVision project qs-rgb.uvproj, settings and files
target qs-rgb (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: qs-rgb
  AfterMake: fromelf --bin --output .\rvmdk\qs-rgb.bin .\rvmdk\qs-rgb.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: qs-rgb.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c rgb.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: qs-rgb.c rgb_commands.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
