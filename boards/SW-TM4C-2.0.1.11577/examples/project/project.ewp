# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F232H5BB TexasInstruments LM4F232H5BB
  ICCARM.CCDefines: ewarm; PART_LM4F232H5BB; TARGET_IS_BLIZZARD_RA3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: project.c startup_ewarm.c
